File: Example Project Complex/MCU.kicad_sch (KiCad schematic)
At the start: 38 parts

Commit message: dont know updates
Parts:
- gave numbers to parts that had none: 38
